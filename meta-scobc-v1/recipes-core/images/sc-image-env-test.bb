DESCRIPTION = "OSL image definition for SC-OBC Module V1"
LICENSE = "MIT"

require sc-image-env-test.inc

IMAGE_NAME_SUFFIX ?= ""
