UBOOT_XLNX_SCR_INCLUDE ?= ""
UBOOT_XLNX_SCR_INCLUDE:dualboot = "u-boot-xlnx-scr-dualboot.inc"

include ${UBOOT_XLNX_SCR_INCLUDE}
