BOOTBIN_INCLUDE ?= ""
BOOTBIN_INCLUDE:dualboot = "xilinx-bootbin-dualboot.inc"

include ${BOOTBIN_INCLUDE}
