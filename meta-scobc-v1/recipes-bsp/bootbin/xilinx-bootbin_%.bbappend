DEPENDS:append = " zephyr-rpu-firmware"
